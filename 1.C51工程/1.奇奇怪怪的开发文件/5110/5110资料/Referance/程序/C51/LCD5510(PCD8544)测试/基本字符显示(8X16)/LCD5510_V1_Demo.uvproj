# Keil uVision project LCD5510_V1_Demo.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89S52 Atmel
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x1FFF) CLOCK(33000000) MODAT2
  output: LCD5510_V1_Demo +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: LCD5510_V1_Demo.C Font_code.C LCD5510_V1.C LCD5510_V1.H
