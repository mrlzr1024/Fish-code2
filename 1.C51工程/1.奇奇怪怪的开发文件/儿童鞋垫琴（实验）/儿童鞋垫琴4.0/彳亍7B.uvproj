# Keil uVision project 彳亍7B.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51RC Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x7FFF)  XRAM(0-0xFF) CLOCK(33000000) MODAT2
  output: 彳亍7B +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\儿童鞋垫琴4.0
  group Source Group 1
    ./: 彳亍7B.c key.c spi.c
