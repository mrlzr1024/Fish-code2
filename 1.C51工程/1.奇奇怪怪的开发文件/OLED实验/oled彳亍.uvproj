# Keil uVision project oled彳亍.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: oled彳亍 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\I2C;..\OLED实验
  group Source Group 1
    ./: main.c
