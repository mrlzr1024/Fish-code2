# Keil uVision project 彳亍8.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51RC Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x7FFF)  XRAM(0-0xFF) CLOCK(33000000) MODAT2
  output: 彳亍8b +hex
  c flags: Optimize=8 SizeSpeed=1
  group New Group
    ./: 彳亍8沙盒.c
