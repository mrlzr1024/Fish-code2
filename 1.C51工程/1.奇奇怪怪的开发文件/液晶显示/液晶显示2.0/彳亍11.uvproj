# Keil uVision project 彳亍11.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51RC Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x7FFF)  XRAM(0-0xFF) CLOCK(33000000) MODP2
  output: 彳亍11
  c flags: Optimize=8 SizeSpeed=1
