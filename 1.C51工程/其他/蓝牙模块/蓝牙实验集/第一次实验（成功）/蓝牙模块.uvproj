# Keil uVision project 蓝牙模块.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: 蓝牙模块 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\蓝牙模块
  group Source Group 1
    ./: 串口通信A.c spi.c
