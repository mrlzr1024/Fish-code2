# Keil uVision project 挖掘机操作系统.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: 挖掘机操作系统 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\源文件Soucre
  group Source Group 1
    ./: 挖掘机.c
    ../源文件Soucre/: I2CA.c PCA9685.c
