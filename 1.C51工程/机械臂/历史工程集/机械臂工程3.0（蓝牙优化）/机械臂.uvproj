# Keil uVision project 机械臂.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: 机械臂 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: arm.c key.c oled.c 串口通信A.c TuringServo.c engine.c
